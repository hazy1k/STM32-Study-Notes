# Keil uVision project Fire_H750.uvprojx, settings and files
target Fire_emxgui (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_emxgui
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,X_GUI_USE_FREERTOS,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\bsp\cm_backtrace;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\app\base;..\..\User\bsp\FATFS;..\..\..\..\..\emXGUI_Lib\app\base\res_writer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group USER
    ../../User/: main.c stm32h7xx_it.c board.h FreeRTOSConfig.h
  group BSP
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/flash/: bsp_qspi_flash.c
    ../../User/bsp/lcd/: bsp_lcd.c
    ../../User/bsp/delay/: core_delay.c
    ../../User/bsp/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../../User/bsp/sd_card/: bsp_sdio_sd.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group emxgui/arch
    ../../../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../../../../emXGUI_Lib/drv/: gui_font_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_startup.c gui_input_port.c gui_touch_port.c gui_fs_port.c gui_resource_port.c
  group emxgui/inc
    ../../../../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h
    ../../../../../emXGUI_Lib/libs/: x_obj.cpp
  group emxgui/libs
    ../../../../../emXGUI_Lib/libs/: emXGUI100_MDK_M7.lib x_libc_MDK_M7.lib libpng_MDK_M7.lib libjpeg_MDK_M7.lib
  group base_app
    ../../../../../emXGUI_Lib/app/base/: gui_desktop.c CListMenu.cpp
    ../../../../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
    ../../../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
  group emxgui/res
    ../../../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group DOC
    ../../: 必读说明.txt
  group Fafts
    ../../User/bsp/FATFS/: diskio.c ff.c ffconf.h ff_gen_drv.c
    ../../User/bsp/FATFS/option/: cc936.c syscall.c
  group OEM_Face
    ../../../../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
