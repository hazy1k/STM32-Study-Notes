# Keil uVision project YH-uCOS-III.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: YH-uCOS-III
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group Doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
